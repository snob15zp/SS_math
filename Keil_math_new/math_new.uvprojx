# Keil uVision project math_new.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: math_new
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __debug__
  c include: ..\Math_MATLAB_20230530;..\Keil_math_new
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group main
    ./: main.c
  group math
    ../Math_MATLAB_20230530/: FilterAC_s19s29_CG.c FilterAC_s19s29_CG.h FilterAC_s19s29_CG_private.h FilterAC_s19s29_CG_types.h FilterC_s19s29_CG1.c FilterC_s19s29_CG1.h FilterC_s19s29_CG1_private.h FilterC_s19s29_CG1_types.h mathfast.c MathFast.h MathSlow.c MathSlow.h multiword_types.h rtmodel.h rtwtypes.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.0
